# Keil uVision project Projet TC  FF-MS1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Projet TC  FF-MS1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main_FF_MS1_Master.c main_FF_MS1_Slave.c c8051F020.h c8051F020_SFR16.h
