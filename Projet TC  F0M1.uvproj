# Keil uVision project Projet TC  F0M1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Projet TC  F0M1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main_F0M1.c FO_M1__Structures_COMMANDES_INFORMATIONS_CentraleDeCommande.h strcmp_test.c
